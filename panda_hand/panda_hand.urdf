Commit message: Fixes to make coordinates consistent

File: panda_hand/panda_hand.urdf (robot description, URDF)
Before this commit: robot panda, 5 links, 4 joints
Joints:
- joint panda_hand_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 1.57079632679
